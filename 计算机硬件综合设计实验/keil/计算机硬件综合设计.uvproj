# Keil uVision project 计算机硬件综合设计.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C51 Atmel
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(24000000)
  output: 计算机硬件综合设计 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: 计算机硬件综合设计.c STARTUP.A51 AT24C02.h DS18B20.h LCD1602.h
